# Keil uVision project UART_transmit.uvprojx, settings and files
target 2go_ee_emu (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: XMC1100-Q024x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.8.0
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: UART_transmit
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XMC1100_Q024x0064
  library: MicroLIB
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source Files
    ./: main.c xmc1100_it.c XMC1000_tseRoutine.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.1.1, Board Support:LED 1.0.0, CMSIS Driver:USART 2.10, Device:RTE_Device 1.1.0, Device:Startup 2.1.0, Device:XMClib:GPIO 2.1.18, Device:XMClib:SCU 2.1.18, Device:XMClib:UART 2.1.18, Compiler:I/O:STDOUT 1.4.0
