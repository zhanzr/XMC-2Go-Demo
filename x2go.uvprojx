# Keil uVision project x2go.uvprojx, settings and files
target x2go (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC1100-Q024x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.10.0
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: x2go +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group source
    ./: main.c xmc1100_it.c led.c XMC1000_tseRoutine.c
  group doc
    ./: README.md
software components: CMSIS:CORE 5.3.0, Device:Startup 2.4.0, Device:XMClib:GPIO 2.1.22, Device:XMClib:RTC 2.1.22, Device:XMClib:SCU 2.1.22, Device:XMClib:UART 2.1.22, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
